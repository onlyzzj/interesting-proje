# Keil uVision project Quadrotor.uvproj, settings and files
target Quadrotor (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Quadrotor +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\FWLIB\inc;..\USER;..\SYSTEM\delay;..\SYSTEM\data_transfer;..\SYSTEM\hmc5883l;..\SYSTEM\iic;..\SYSTEM\mpu6050;..\SYSTEM\usart;..\SYSTEM\led;..\SYSTEM\ms5611;..\SYSTEM\imu;..\SYSTEM\math
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_i2c.c stm32f4xx_usart.c stm32f4xx_tim.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/hmc5883l/: hmc5883l.c
    ../SYSTEM/mpu6050/: mpu6050.c
    ../SYSTEM/iic/: iic.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/data_transfer/: data_transfer.c
    ../SYSTEM/led/: led.c
    ../SYSTEM/ms5611/: ms5611.c
    ../SYSTEM/imu/: imu.c
    ../SYSTEM/math/: math.c
  group NOTE
    ../Note/: 结构体 共同体 枚举体.txt 强制类型转换.txt 数据类型.txt 数组.txt 指针.txt
